inherit externalsrc
EXTERNALSRC = "/home/vanson/working/yocto-live/meta-yocto-live/recipes-devtool/sources/this-is"

# initial_rev: 99881898113cf78f5a986e8960fda9a3896c302e
